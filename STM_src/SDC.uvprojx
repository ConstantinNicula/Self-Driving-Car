# Keil uVision project SDC.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: WifiDebug
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HSE_VALUE=12000000
  c include: .\control_lib\lib;.\encoder_libs\inc;.\espclient_libs\inc;.\sensor_libs\inc;.\motor_libs\inc;.\retarget_libs\inc;.\sensor_libs\inc;.\setup_libs\inc;.\status_libs\inc;.\utility_libs\inc;.\imu_libs\inc;.\color_libs\libs
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: main.c
  group ESPClient
    ./espclient_libs/src/: ESPClient.c
    ./espclient_libs/inc/: ESPClient.h
  group MotorControl
    ./motor_libs/src/: motorControl.c
    ./motor_libs/inc/: motorControl.h
  group Retarget
    ./retarget_libs/src/: retarget.c
    ./retarget_libs/inc/: retarget.h
  group Setup
    ./setup_libs/src/: Setup.c
    ./setup_libs/inc/: Setup.h
  group Utility
    ./utility_libs/src/: Delay.c
    ./utility_libs/inc/: Delay.h
  group Encoder
    ./encoder_libs/inc/: encoder.h
    ./encoder_libs/src/: encoder.c
  group Control
    ./control_lib/lib/: control.h
    ./control_lib/src/: control.c
  group Status
    ./status_libs/src/: battery.c
    ./status_libs/inc/: battery.h
  group IMU
    ./imu_libs/inc/: LSM6DS33.h I2CRoutines.h
    ./imu_libs/src/: LSM6DS33.c I2CRoutines.c
  group Distance Sensors
    ./sensor_libs/src/: SensorBar.c mux.c
    ./sensor_libs/inc/: SensorBar.h
  group Color Sensor
    ./color_libs/src/: TCS34725.c
    ./color_libs/libs/: TCS34725.h
software components: CMSIS:CORE 5.0.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
